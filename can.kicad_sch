File: can.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U14 SN65HVD232

Commit message: Update
Parts:
- C57: Voltage 50V -> 100V
